Commit message: pushed final file structure

File: Global_Path_Planner/helper_files/costom_plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=100 100 10; visual mesh filename=meshes/plane.obj scale=2 4 1
